## station/build/defconfig
```kconfig
CONFIG_ESP_WIFI_SSID="Kon peko"
CONFIG_ESP_WIFI_PASSWORD="pekopeko"
# CONFIG_ESP_WIFI_SOFTAP_SUPPORT is not set
```
